# Keil uVision project GREMSY_GIMBAL_JIG_TEST_FULL_v200.uvprojx, settings and files
target GREMSY_GIMBAL_JIG_TEST_FULL_v200 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: GREMSY_GIMBAL_JIG_TEST_GIMBAL_2AXIS_FSTD_v201 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F405xx,USE_FULL_LL_DRIVER
  c include: ../Core/Inc;              ../Drivers/STM32F4xx_HAL_Driver/Inc;              ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;              ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;              ../Drivers/CMSIS/Include;              ..\JIG_TEST\Inc;              ..\DJI_CAN\Inc;              ..\SSD1306\Inc;              ..\mavlink_v2;              ..\mavlink_v2\ardupilotmega;              ..\mavlink_v2\common;../FATFS/Target;../FATFS/App;../USB_HOST/App;../USB_HOST/Target;../Middlewares/Third_Party/FatFs/src;../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group JIG_TEST
    ../JIG_TEST/Src/: timeOut.c ppm.c JIG_TEST_ppm_gimbal.c JIG_TEST_can_dji_.c JIG_TEST_sbus_gimbal.c JIG_TEST_display.c serialPort.c mavlinkProtocol.c JIG_TEST_mavlink_gimbal.c JIG_TEST_gimbal_FSTD.c JIG_TEST_console.c JIG_TEST_comm_raspberry.c JIG_TEST_button.c JIG_TEST_aux.c JIG_TEST_rtc.c JIG_TEST_comm_raspberry_v2.c JIG_TEST_gimbal_FSTD_v2.c JIG_TEST_display_v2.c stm32f40x_flash.c JIG_TEST_CommEsp32.c File_Handling.c
  group DJI_CAN
    ../DJI_CAN/Src/: can_dji_camera.c can_dji_gimbal.c can_dji_remote.c can_dji.c can_dji_protocol.c
  group SSD1306
    ../SSD1306/Src/: ssd1306.c ssd1306_fonts.c
  group note
    ../JIG_TEST/Src/: note.txt param_gimbal.txt
  group Application/User/FATFS/Target
    ../FATFS/Target/: usbh_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Application/User/USB_HOST/App
    ../USB_HOST/App/: usb_host.c
  group Application/User/USB_HOST/Target
    ../USB_HOST/Target/: usbh_conf.c usbh_platform.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_rcc.c stm32f4xx_ll_utils.c stm32f4xx_ll_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_ll_rtc.c stm32f4xx_ll_gpio.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
software components: CMSIS:CORE 4.3.0
